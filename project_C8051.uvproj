# Keil uVision project project_C8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F350 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(50000000)
  output: project_C8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group
    ./: STARTUP.A51
    ./scr/: 1602_4bit.c
  group user
    ./user/: main.c
